# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6190000::V6.19::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../;..\source\third_party\CMSIS\Core\Include;..\source;..\OLED;..\EC11;..\KEY;..\MOTOR;..\MPU6050;..\MPU6050\eMPL;..\GRAY;..\STEP_MOTOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c interrupt.c bsp_printf.c bsp_printf.h interrupt.h
    ./: startup_mspm0g350x_uvision.s
  group OLED
    ../OLED/: OLED.c OLED_Data.c OLED.h OLED_Data.h
  group EC11
    ../EC11/: ec11.c ec11.h
  group MOTOR
    ../MOTOR/: motor.c pid.c motor.h encoder.c pid.h encoder.h
  group GRAY
    ../GRAY/: No_Mcu_Ganv_Grayscale_Sensor_Config.c No_Mcu_Ganv_Grayscale_Sensor_Config.h
  group MPU6050
    ../MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c bsp_iic.c bsp_systick.c
  group KEY
    ../KEY/: key.c key.h
  group STEP_MOTOR
    ../STEP_MOTOR/: step_motor.c step_motor.h
